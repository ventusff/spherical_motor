# Keil uVision project standard.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: standard
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER, __FPU_PRESENT=1, __FPU_USED=1, ARM_MATH_CM4
  c include: .\app;.\bsp;.\Libraries\CMSIS\Core_Support;.\Libraries\CMSIS\Device_Support;.\Libraries\CMSIS\Device_Support\Startup;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\STM32F4xx_StdPeriph_Driver\src;.\bsp\bsp_ADNS9800
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup Code
    ./Libraries/CMSIS/Device_Support/Startup/: startup_stm32f40xx.s
  group CMSIS
    ./Libraries/CMSIS/Device_Support/: system_stm32f4xx.c
    ./Libraries/CMSIS/: arm_cortexM4lf_math.lib
  group Bsp
    ./bsp/: bsp.c timer.c usart.c bsp_ADC.c bsp_motor_drive.c bsp_DAC.c bsp_Key.c
    ./bsp/bsp_ADNS9800/: A9800Srom.c bsp_ADNS9800.c
  group App
    ./app/: main.c stm32f4xx_it.c app_TimingCheck.c app_Main_PID.c app_Decouple.c configuration.c app_Rotor_Rotate.c
    ./App/: app_Sub_PID_current.c
  group Standard_Periph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
